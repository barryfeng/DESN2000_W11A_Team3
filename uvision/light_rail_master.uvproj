# Keil uVision project light_rail_master.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: light_rail_master
  c flags: Optim=1
  c include: ..\motion_control;..\system;..\..\DESN2000_W11A_Team3;..\diagnostics;..\logging;..\user_interface;..\user_interface\LCD;..\user_interface\touchscreen
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: LPC2400.s
    ../: LPC24XX.h master_controller.c
  group motion_control
    ../motion_control/: fixed_point_pid.c motion_controller.c
  group system
    ../system/: system_init.c system_timer.c
  group logging
    ../logging/: access_data.c data_management.s exception_vector_table.s swi_handler.s
  group diagnostics
    ../diagnostics/: diagnostics.c SPI_MMC.c
  group user_interface
    ../user_interface/: delay.c
    ../user_interface/touchscreen/: button_press.c touch.c touch_screen_read.c
    ../user_interface/LCD/: font5x7.c fontBrakeLabel.c fontVel.c fontVelLabel.c lcd_grph.c lcd_hw.c lcd_main.c sdram.c
